# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\key_matrix;.\App\lcd1602;.\Public;.\User;.\App\key_fun;.\App\beep
  group User
    ./User/: main.c
  group App
    ./App/lcd1602/: lcd1602.h lcd1602.c
    ./App/key_matrix/: key_matrix.h key_matrix.c
    ./App/key_fun/: key_fun.h
    ./: key_fun.c
    ./App/beep/: beep.h beep.c
  group Public
    ./Public/: public.h public.c
